# Keil uVision project OpelCan.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OpelCan +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, DEBUG_EN
  c include: .\Libraries\CMSIS\Core;.\Libraries\CMSIS\Config;.\Libraries\CMSIS\Startup;.\Libraries\StdPeriph_Lib_V3.5.0\inc;.\Libraries\USB-FS_Lib_V4.1.0\inc;.\Source;.\Source\Debug;.\Source\Peripheral;.\Source\Peripheral\USB;.\Source\Software;.\Source\Common;.\Source\Software\Bus
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./Libraries/CMSIS/Config/: system_stm32f10x.c
    ./Libraries/CMSIS/Startup/: startup_stm32f10x_md.s
    ./Libraries/CMSIS/Core/: core_cm3.c
  group StdPeriph
    ./Libraries/StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Source
    ./Source/: main.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group Peripheral
    ./Source/Peripheral/: TIM4.c CAN1.c USB0.c USART1.c USART3.c
  group Software
    ./Source/Software/: SWtimer.c RoundBuffer.c defs.h CanHacker.c
  group USB
    ./Source/Peripheral/USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c hw_config.c usb_vcp.c
  group USB-FS-Lib
    ./Libraries/USB-FS_Lib_V4.1.0/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Debug
    ./Source/Debug/: debug.c debug_common.c printf_user.c
  group Common
    ./Source/Common/: common.c
  group Bus
    ./Source/Software/Bus/: bus_worker.c LS_Can.c MS_Can.c HS_Can.c
target Debug_CanHacker (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: OpelCan +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, DEBUG_EN, USE_CAN_HACKER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Release (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: OpelCan +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Release_CanHacker (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: OpelCan +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, USE_CAN_HACKER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
